# Keil uVision project Template.uvproj, settings and files
target PixelC3 (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Template +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\STM32F10x_FWLib\inc;..\USER;..\SYSTEM;..\SOLGUI;..\SOLGUI\Font;..\PIXELC_BSP;..\PIXELC_BSP\pixelC_HW_SDcard_FATFS0.09b;..\PIXELC_BSP\pixelC_HW_SDcard_FATFS0.09b\option;..\USB\LIB;..\USB\USB_MassStorage;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORTS
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/: bit.c strprintf.c sys.c delay.c simuspi.c simui2c.c
  group SOLGUI
    ../SOLGUI/Font/: Font4x6_ASCII.c Font6x8_ASCII.c Font8x8_ASCII.c Font8x10_ASCII.c
    ../SOLGUI/: SOLGUI_Hardware.c SOLGUI_Common.c SOLGUI_Printf.c SOLGUI_GBasic.c SOLGUI_Picture.c SOLGUI_Menu.c SOLGUI_Widget.c
  group UCOSII
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ../UCOSII/PORTS/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group PIXELC_BSP
    ../PIXELC_BSP/: BSP_OLED.c BSP_SD.c BSP_FlagLight.c BSP_Key.c BSP_Flash.c
  group FATFS
    ../PIXELC_BSP/pixelC_HW_SDcard_FATFS0.09b/: diskio.c ff.c
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
